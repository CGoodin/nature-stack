Commit message: Updated nature stack configurations

File: config/example_bot.urdf (robot description, URDF)
Before this commit: robot avt_bot, 2 links, 1 joints
Joints:
- joint lidar_joint: origin xyz=0.0 0.0 1.0 rpy=0.0 0.0 0.0 -> xyz=-0.5 0.0 2.5 rpy=0.0 0.0 0.0
